<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Bat_Pack_Gen1.ewp</path>
  </project>
  <batchBuild />
</workspace>
